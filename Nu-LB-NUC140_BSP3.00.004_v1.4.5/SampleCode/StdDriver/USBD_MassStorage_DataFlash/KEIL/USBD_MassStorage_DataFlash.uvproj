# Keil uVision project USBD_MassStorage_DataFlash.uvproj, settings and files
target USBD_MassStorage_DataFlash (ARM-ADS)
  device: NUC120VE3DN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_MassStorage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group User
    ../: descriptors.c main.c MassStorage.c DataFlashProg.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c fmc.c clk.c sys.c
