# IAR project fmc_rw.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC100DN series Nuvoton NUC100DN series (NUC100DN,NUC120DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_rw.bin
  ILINK.IlinkOutputFile: fmc_rw.out
  ILINK.IlinkIcfFile: fmc_rw.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/IAR/: startup_NUC100Series.s
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
