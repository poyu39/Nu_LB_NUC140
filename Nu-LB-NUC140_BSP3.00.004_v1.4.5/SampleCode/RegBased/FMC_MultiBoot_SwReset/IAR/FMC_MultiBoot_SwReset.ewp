# IAR project FMC_MultiBoot_SwReset.ewp, settings and files
configuration FMC_MultiBoot_SwReset (ARM)
  General.OGChipSelectEditMenu: NUC100DN series Nuvoton NUC100DN series (NUC100DN,NUC120DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; BOOTADDR=0x0000
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_MultiBoot_SwReset.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot_SwReset.out
  ILINK.IlinkIcfFile: FMC_MultiBoot_SwReset.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration FMC_Boot0 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; BOOTADDR=0x1000
  OBJCOPY.OOCOutputFile: FMC_Boot0.bin
  ILINK.IlinkOutputFile: FMC_Boot0.out
  ILINK.IlinkIcfFile: FMC_Boot0.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; BOOTADDR=0x2000
  OBJCOPY.OOCOutputFile: FMC_Boot1.bin
  ILINK.IlinkOutputFile: FMC_Boot1.out
  ILINK.IlinkIcfFile: FMC_Boot1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; BOOTADDR=0x3000
  OBJCOPY.OOCOutputFile: FMC_Boot2.bin
  ILINK.IlinkOutputFile: FMC_Boot2.out
  ILINK.IlinkIcfFile: FMC_Boot2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; BOOTADDR=0x4000
  OBJCOPY.OOCOutputFile: FMC_Boot3.bin
  ILINK.IlinkOutputFile: FMC_Boot3.out
  ILINK.IlinkIcfFile: FMC_Boot3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/IAR/: startup_NUC100Series.s
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
