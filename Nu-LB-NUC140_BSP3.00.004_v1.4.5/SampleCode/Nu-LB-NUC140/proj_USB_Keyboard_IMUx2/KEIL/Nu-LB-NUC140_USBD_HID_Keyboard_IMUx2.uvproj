# Keil uVision project Nu-LB-NUC140_USBD_HID_Keyboard_IMUx2.uvproj, settings and files
target USBD_HID_Keyboard_IMUx2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Nu-LB-NUC140\Include;..\..\..\..\Library\NuMakerLib\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Library
    ../../../../Library/StdDriver/src/: usbd.c sys.c clk.c fmc.c gpio.c i2c.c spi.c
  group User
    ../: main.c hid_kb.c descriptors.c
    ../../../../Library/Nu-LB-NUC140/Source/: SYS_init.c LCD.c I2Cdev.c NVT_I2C.c
    ../../../../Library/NuMakerLib/Source/: MPU6050.c
