# Keil uVision project Nu-LB-NUC140_USBD_MassStorage.uvproj, settings and files
target USBD_MassStorage_DataFlash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_MassStorage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Nu-LB-NUC140\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c fmc.c clk.c sys.c gpio.c
  group User
    ../: main.c descriptors.c DataFlashProg.c MassStorage.c
    ../../../../Library/Nu-LB-NUC140/Source/: SYS_init.c
