# Keil uVision project Nu-LB-NUC140.uvproj, settings and files
target pokemon (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: pokemon
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\NUC100Series\Include;..\..\Library\Nu-LB-NUC140\Include;..\;..\..\Library
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Library
    ../../Library/StdDriver/src/: clk.c spi.c sys.c gpio.c timer.c
  group User
    ../: main.c pokemon.c
    ../../Library/Nu-LB-NUC140/Source/: SYS_init.c NewLCD.c NewScankey.c NewSevenSegment.c
